; ============================================================
; basic_tokens.inc - liste UNIQUE des mots-cles du BASIC (lib/basic.asm).
; Chaque ligne KW nom, 'TEXTE', gestionnaire est expansee TROIS fois selon
; KW_MODE: 2 = definit le jeton T_<nom> (80h + rang), 0 = table des textes
; (kw_table), 1 = table des gestionnaires (tok_handlers, un mot par jeton,
; 0 = jeton sans gestionnaire propre). L'ORDRE DES LIGNES = numero de jeton.
;   - instructions: appelees par "jmp [cs:tok_handlers+2*(jeton-80h)]", elles
;     se terminent par "jmp bas_newstt".
;   - fonctions (de T_SGN a T_DATES): appelees par "call", resultat dans FAC.
; ============================================================
; --- instructions ---
KW END,     'END',        st_end
KW FOR,     'FOR',        st_for
KW NEXT,    'NEXT',       st_next
KW DATA,    'DATA',       st_data
KW INPUT,   'INPUT',      st_input
KW DIM,     'DIM',        st_dim
KW READ,    'READ',       st_read
KW LET,     'LET',        st_let
KW GOTO,    'GOTO',       st_goto
KW RUN,     'RUN',        st_run
KW IF,      'IF',         st_if
KW RESTORE, 'RESTORE',    st_restore
KW GOSUB,   'GOSUB',      st_gosub
KW RETURN,  'RETURN',     st_return
KW REM,     'REM',        st_rem
KW STOP,    'STOP',       st_stop
KW PRINT,   'PRINT',      st_print
KW CLEAR,   'CLEAR',      st_clear
KW LIST,    'LIST',       st_list
KW NEW,     'NEW',        st_new
KW ON,      'ON',         st_on
KW WAIT,    'WAIT',       st_wait
KW DEF,     'DEF',        st_def
KW POKE,    'POKE',       st_poke
KW CONT,    'CONT',       st_cont
KW OUT,     'OUT',        st_out
KW CLS,     'CLS',        st_cls
KW WHILE,   'WHILE',      st_while
KW WEND,    'WEND',       st_wend
KW SWAP,    'SWAP',       st_swap
KW ERASE,   'ERASE',      st_erase
KW RANDOMIZE, 'RANDOMIZE', st_randomize
KW CALL,    'CALL',       st_call
KW LOCATE,  'LOCATE',     st_locate
KW COLOR,   'COLOR',      st_color
KW BEEP,    'BEEP',       st_beep
KW DELETE,  'DELETE',     st_delete
KW TRON,    'TRON',       st_tron
KW TROFF,   'TROFF',      st_troff
KW DEFINT,  'DEFINT',     st_defint
KW DEFSNG,  'DEFSNG',     st_defsng
KW DEFDBL,  'DEFDBL',     st_defsng
KW DEFSTR,  'DEFSTR',     st_defstr
KW SYSTEM,  'SYSTEM',     st_system
KW BYE,     'BYE',        st_system
KW LINE,    'LINE',       st_line
KW EDIT,    'EDIT',       st_edit
KW SAVE,    'SAVE',       st_save
KW LOAD,    'LOAD',       st_load
KW MERGE,   'MERGE',      st_merge
KW FILES,   'FILES',      st_files
KW KILL,    'KILL',       st_kill
KW FORMAT,  'FORMAT',     st_format
KW OPEN,    'OPEN',       st_open
KW CLOSE,   'CLOSE',      st_close
KW WRITE,   'WRITE',      st_write
KW DSKREAD, 'DSKREAD',    st_dskread
KW DSKWRITE, 'DSKWRITE',  st_dskwrite
KW USB,     'USB',        st_usb
KW BOOT,    'BOOT',       st_boot
KW HELP,    'HELP',       st_help
KW SQ,      "'",          st_rem
; --- mots sans gestionnaire propre ---
KW ELSE,    'ELSE',       0
KW THEN,    'THEN',       0
KW TO,      'TO',         0
KW STEP,    'STEP',       0
KW SEG,     'SEG',        0
KW FN,      'FN',         0
KW USING,   'USING',      0
KW TAB,     'TAB(',       0
KW SPC,     'SPC(',       0
KW NOT,     'NOT',        0
KW AND,     'AND',        0
KW OR,      'OR',         0
KW XOR,     'XOR',        0
KW EQV,     'EQV',        0
KW IMP,     'IMP',        0
KW MOD,     'MOD',        0
; --- fonctions ---
KW SGN,     'SGN',        fn_sgn
KW INT,     'INT',        fn_int
KW ABS,     'ABS',        fn_abs
KW SQR,     'SQR',        fn_sqr
KW RND,     'RND',        fn_rnd
KW SIN,     'SIN',        fn_sin
KW COS,     'COS',        fn_cos
KW TAN,     'TAN',        fn_tan
KW ATN,     'ATN',        fn_atn
KW LOG,     'LOG',        fn_log
KW EXP,     'EXP',        fn_exp
KW FIX,     'FIX',        fn_fix
KW CINT,    'CINT',       fn_cint
KW CSNG,    'CSNG',       fn_csng
KW CDBL,    'CDBL',       fn_csng
KW PEEK,    'PEEK',       fn_peek
KW INP,     'INP',        fn_inp
KW POS,     'POS',        fn_pos
KW FRE,     'FRE',        fn_fre
KW LEN,     'LEN',        fn_len
KW ASC,     'ASC',        fn_asc
KW VAL,     'VAL',        fn_val
KW INSTR,   'INSTR',      fn_instr
KW CHRS,    'CHR$',       fn_chrs
KW STRS,    'STR$',       fn_strs
KW HEXS,    'HEX$',       fn_hexs
KW OCTS,    'OCT$',       fn_octs
KW LEFTS,   'LEFT$',      fn_lefts
KW RIGHTS,  'RIGHT$',     fn_rights
KW MIDS,    'MID$',       fn_mids
KW STRINGS, 'STRING$',    fn_strings
KW SPACES,  'SPACE$',     fn_spaces
KW INKEYS,  'INKEY$',     fn_inkeys
KW INPUTS,  'INPUT$',     fn_inputs
KW LCASES,  'LCASE$',     fn_lcases
KW UCASES,  'UCASE$',     fn_ucases
KW TIMER,   'TIMER',      fn_timer
KW TIMES,   'TIME$',      fn_times
KW DATES,   'DATE$',      fn_dates
KW EOF,     'EOF',        fn_eof
